## boards/shields/basic_numpad/boards/shields/basic_numpad/Kconfig.defconfig
```kconfig
if SHIELD_BASIC_NUMPAD

config ZMK_KEYBOARD_NAME
    default "Basic Numpad"

endif
```
